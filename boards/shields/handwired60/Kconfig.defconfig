## boards/shields/handwired60/Kconfig.defconfig
```kconfig
if SHIELD_HANDWIRED60

config ZMK_KEYBOARD_NAME
    default "handwired60"

endif # SHIELD_HANDWIRED60
```
